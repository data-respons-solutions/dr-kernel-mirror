## drivers/misc/ctgw-smc/Kconfig
```kconfig
config CTGW_MCU
	tristate "Enable DR Gateway SMC controller"
	depends on I2C
	help
	  Bring in the multi-function SMC device
```
